Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-05-17T14:23:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 17 14:23:25 2024 * Host: 105VN589 * Database: C:\Users\truole\AppData\Local\Temp\{96A9FCB2-7786-4DA4-B993-25178BC1D02F}\ifc * Database version: 5507 * Database creation date: Fri May 17 14:23:25 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 17 14:23:25 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 17 14:23:25 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\Truong Le\RFA 3D\GSEXL1020_216_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GSEXL1020_216_4, GSEXL1020_216_4:GSEXL1020_216_4:213539
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: GSEXL1020/216/4
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.000468535 m3
Other - Category: Structural Connections; Family: GSEXL1020_216_4: GSEXL1020_216_4; Family and Type: GSEXL1020_216_4: GSEXL1020_216_4; Schedule Level: Level: Level 1; Type: GSEXL1020_216_4: GSEXL1020_216_4; Type Id: GSEXL1020_216_4: GSEXL1020_216_4; Family Name: GSEXL1020_216_4
Phasing - Phase Created: New Construction
General - Density: 3.34; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSEXL1020/216/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model: GSEXL1020/216/4; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0297874827110767976925828129658202860931; Name: GSEXL1020/216/4; ObjectType: GSEXL1020/216/4; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: GSEXL1020_216_4; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
